<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\EnddeviceApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>EnddeviceApp</project>
        <configuration>DemoEB</configuration>
      </member>
      <member>
        <project>EnddeviceApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>EnddeviceApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>EnddeviceApp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


